# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: useless +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\useless
  group Source Group 1
    ./: main.c
