# Keil uVision project jichu.uvproj, settings and files
target jichu (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: jichu +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c
  group diaoyong
    ./: led.c smg.c beep.c key.c led_dz.c
